# Keil uVision project RASLibTest.uvproj, settings and files
target RASLibTest (ARM-ADS)
  device: LM4F120H5QR Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: RASLibTest
  c flags: Optim=1
  c include: ..;..\;..\RASLib\inc;C:\Stellarisware;..\Stellarisware
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Sources
    ../RASLib/output/: RASLib.lib
    ../RASLib/src/: Startup.s
    ./: handlers.c main.c
